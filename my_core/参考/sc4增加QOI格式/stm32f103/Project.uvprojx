# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;..\SCGUI;..\SCGUI\touch_lib;..\SCGUI\example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group User
    ./User/: main.c stm32f10x_it.c encoder.c BSP_Common.c LCD_SPI.c stm32f103_flash_hard_stdspi_port.c w25qxx.c
  group SCGUI
    ../SCGUI/: sc_arc.c sc_common.c sc_event_task.c sc_gui.c sc_lvgl_font.c sc_menu.c sc_transform.c sc_indexQOI.c
  group SCGUI/font
    ../SCGUI/font/: lv_font_12.c lv_font_16.c lv_font_20.c
  group SCGUI/bmp
    ../SCGUI/bmp/: bashen.c test_img.c watch_106_64.c watch_h.c QOI_img_.c watch_m.c watch_s.c kof97b.c watch_bg_qoi.c
  group SCGUI/touch_lib
    ../SCGUI/touch_lib/: sc_obj.c sc_heap.c sc_keyboard.c sc_widget.c
  group SCGUI/touch_lib/widget
    ../SCGUI/touch_lib/widget/: sc_arc.c sc_button.c sc_canvas.c sc_image.c sc_label.c sc_line_edit.c sc_rotate.c sc_text_box.c
  group SCGUI/example
    ../SCGUI/example/: sc_demo_test.c sc_demo_simple.c sc_demo_widget.c
