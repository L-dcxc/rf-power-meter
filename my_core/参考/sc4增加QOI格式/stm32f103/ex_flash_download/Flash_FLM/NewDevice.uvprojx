# Keil uVision project NewDevice.uvprojx, settings and files
target FLM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SC_STM32F103_W25Q128
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Library;..\Flash_FLM;..\..\Start
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group bsp
    ./: stm32f103_flash_soft_stdspi_port.c stm32f103_flash_hard_stdspi_port.c w25qxx.c
  group Library
    ../../Library/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_dma.c
    ../../Start/: system_stm32f10x.c
